# Keil uVision project PriojAllComble.uvproj, settings and files
target PriojAllComble (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: base_empty
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: .\CMSI\inc;.\CMSI;.\FWlib;.\FWlib\inc;.\FWlib\src;.\listing;.\user;.\user\inc;.\user\src;..\UCOS_III\uC-CPU;..\UCOS_III\uC-CPU\ARM-Cortex-M4\RealView;..\UCOS_III\uC-LIB;..\UCOS_III\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOS_III\uCOS-III;..\UCOS_III\uCOS-III\Source;..\UCOS_III\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\UCOS_III\UcosCfg;.\user\Bsp\inc;.\user\Bsp\LCD\inc;..\EmWin;..\EmWin\Fonts;..\EmWin\GUI_Config;..\EmWin\GUI_DEMO;..\EmWin\GUI_DEMO\emWinDemo;..\EmWin\GUI_Driver;..\EmWin\GUI_Lib;..\EmWin\GUI_X;..\EmWin\Include;..\EmWin\LCD_Driver;..\EmWin\LCD_Driver\inc;..\EmWin\Fonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ./user/src/: Task_GUI.c LCD_interface.c GUI_Fist_Page.c GUI_DraweSing.c Task_dateConnected.c Task_DtuDely.c
  group USER
    ./user/: main.c stm32f4xx_it.c stm32f4xx_conf.h
  group BSP
    ./user/: bsp.c bsp_os.c
    ./user/Bsp/src/: Bsp_Led.c Bsp_Usart1.c Bsp_Touch_SPI.c Bsp_Usart2.c Bsp_Timers.c Bsp_Usart3.c
  group DataConversion
    ./user/src/: exchangeData.c
  group StartUp
    ./CMSI/: startup_stm32f4xx.s
    ./user/: system_stm32f4xx.c
  group FwLib
    ./FWlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group uc/cfg
    ../UCOS_III/UcosCfg/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group uc/cup
    ../UCOS_III/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../UCOS_III/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uc/lib
    ../UCOS_III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../UCOS_III/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group ucos/source
    ../UCOS_III/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group ucos/port
    ../UCOS_III/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group EmWin/LcdDriver
    ../EmWin/LCD_Driver/src/: BspLCDDrive.c BspLcdHal_Init.c Font.c
    ../EmWin/GUI_Driver/: GUIDRV_Template.c
  group EmWin/GUI_X
    ../EmWin/GUI_X/: GUI_VNC_X.c GUI_X.c GUI_X_Touch_Analog.c
  group EmWin/GUI_Config
    ../EmWin/GUI_Config/: GUIConf.c GUIConf.h LCDConf.c LCDConf.h
  group EmWin/GUI_Lib
    ../EmWin/GUI_Lib/: STemWin522_CM4_OS_Keil.lib
